Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB-2412-12-000-DG - 4 Panel V-Groove.IFC
Time: 2024-11-05T11:54:43+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 33.1386079999997634; Volume Measure: 0.0331386079999998; Area Measure: 6.0146170982424563

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 33.1386079999997634; Volume Measure: 0.0331386079999998; Area Measure: 6.0146170982424563

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 33.1386079999997634; Volume Measure: 0.0331386079999998; Area Measure: 6.0146170982424563

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
E3DB-2412-12-000-DG - 4 Panel V-Groove | PSet_Mass_Property - Mass Measure: 33.1386079999997634; Volume Measure: 0.0331386079999998; Area Measure: 6.0146170982424563
E3DB-2412-12-000-DG - 4 Panel V-Groove | SOLIDWORKS Custom Properties - Description: 4 PANEL V-GROOVE; PartNo: E3DB-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
