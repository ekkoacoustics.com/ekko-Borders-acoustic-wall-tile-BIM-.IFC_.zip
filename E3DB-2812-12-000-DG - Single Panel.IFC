Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB-2812-12-000-DG - Single Panel.IFC
Time: 2024-11-05T11:52:07+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 40.3200000000000003; Volume Measure: 0.0403200000000000; Area Measure: 7.1711999999999998

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 40.3200000000000003; Volume Measure: 0.0403200000000000; Area Measure: 7.1711999999999998

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 40.3200000000000003; Volume Measure: 0.0403200000000000; Area Measure: 7.1711999999999998

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
E3DB-2812-12-000-DG - Single Panel | PSet_Mass_Property - Mass Measure: 40.3200000000000003; Volume Measure: 0.0403200000000000; Area Measure: 7.1711999999999998
E3DB-2812-12-000-DG - Single Panel | SOLIDWORKS Custom Properties - PartNo: E3DB-2812-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: HORIZONTAL THRU CUT + RAISED PANEL & GLUED POSITION TBC; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Description: SINGLE PANEL; Project: EKKO PRODUCT LIST; sets with these values: 2
