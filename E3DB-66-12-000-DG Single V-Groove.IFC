Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB-66-12-000-DG Single V-Groove.IFC
Time: 2024-11-05T11:55:52+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 4.2247440000000003; Volume Measure: 0.0042247440000000; Area Measure: 0.7600732363135461

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 4.2247440000000003; Volume Measure: 0.0042247440000000; Area Measure: 0.7600732363135461

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 4.2247440000000003; Volume Measure: 0.0042247440000000; Area Measure: 0.7600732363135461

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
E3DB-66-12-000-DG Single V-Groove | PSet_Mass_Property - Mass Measure: 4.2247440000000003; Volume Measure: 0.0042247440000000; Area Measure: 0.7600732363135461
E3DB-66-12-000-DG Single V-Groove | SOLIDWORKS Custom Properties - Description: SINGLE V-GROOVE; PartNo: E3DB-66-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
