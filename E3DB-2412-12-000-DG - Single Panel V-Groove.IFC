Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB-2412-12-000-DG - Single Panel V-Groove.IFC
Time: 2024-11-05T11:54:17+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 33.9241759999984964; Volume Measure: 0.0339241759999985; Area Measure: 5.9216476925949468

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 33.9241759999984964; Volume Measure: 0.0339241759999985; Area Measure: 5.9216476925949468

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 33.9241759999984964; Volume Measure: 0.0339241759999985; Area Measure: 5.9216476925949468

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
E3DB-2412-12-000-DG - Single Panel V-Groove | PSet_Mass_Property - Mass Measure: 33.9241759999984964; Volume Measure: 0.0339241759999985; Area Measure: 5.9216476925949468
E3DB-2412-12-000-DG - Single Panel V-Groove | SOLIDWORKS Custom Properties - Description: SINGLE PANEL V-GROOVE; PartNo: E3DB-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
