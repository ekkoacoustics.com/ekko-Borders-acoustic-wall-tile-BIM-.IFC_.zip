Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB - Borders Various Panels.IFC
Time: 2024-11-05T11:51:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 656.3810397599976341; Volume Measure: 0.6563810397599975; Area Measure: 119.1472836528419492

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 656.3810397599976341; Volume Measure: 0.6563810397599975; Area Measure: 119.1472836528419492

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 656.3810397599976341; Volume Measure: 0.6563810397599975; Area Measure: 119.1472836528419492

# IfcBuildingElementProxy (19)
In: default BuildingStorey
Name | Description | PartNo | Revision | Material | Finish | CheckedBy | DrawnBy | Client | Project | sets with these values
E3DB - Borders Various Panels.SLDPRT | PSet_Mass_Property - Mass Measure: 656.3810397599976341; Volume Measure: 0.6563810397599975; Area Measure: 119.1472836528419492
E3DB-2412-12-000-DG - 3 Panel | 3 PANEL | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2412-12-000-DG - 2 Panel | 2 PANEL | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2412-12-000-DG - 2 Panel V-Groove | 2 PANEL V-GROOVE | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2412-12-000-DG - 3 Panel V-Groove | 3 PANEL V-GROOVE | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP V-GROOVE | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-66-12-000-DG Single Panel | SINGLE PANEL | E3DB-66-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - 2 Panel V-Groove | 2 PANEL V-GROOVE | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP V-GROOVE | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - 3 Panel V-Groove | 3 PANEL V-GROOVE | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - 2 Panel | 2 PANEL | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - 4 Panel V-Groove | 4 PANEL V-GROOVE | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP V-GROOVE | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2412-12-000-DG - 4 Panel V-Groove | 4 PANEL V-GROOVE | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP V-GROOVE | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - Single Panel | SINGLE PANEL | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2412-12-000-DG - 4 Panel | 4 PANEL | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2412-12-000-DG - Single Panel | SINGLE PANEL | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2412-12-000-DG - Single Panel V-Groove | SINGLE PANEL V-GROOVE | E3DB-2412-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP V-GROOVE | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - 3 Panel | 3 PANEL | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - 4 Panel | 4 PANEL | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-2812-12-000-DG - Single Panel V-Groove | SINGLE PANEL V-GROOVE | E3DB-2812-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP V-GROOVE | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
E3DB-66-12-000-DG Single V-Groove | SINGLE V-GROOVE | E3DB-66-12-000-DG | A | 12MM EKKO ACOUSTIC PANEL | 14MM WIDE X 7MM DEEP | DG | CAM | EKKO | EKKO PRODUCT LIST | 2
