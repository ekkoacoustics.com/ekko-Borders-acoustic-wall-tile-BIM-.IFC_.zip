Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB-2412-12-000-DG - Single Panel.IFC
Time: 2024-11-05T11:54:04+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 34.5599999999999952; Volume Measure: 0.0345600000000000; Area Measure: 6.1632000000000016

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 34.5599999999999952; Volume Measure: 0.0345600000000000; Area Measure: 6.1632000000000016

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 34.5599999999999952; Volume Measure: 0.0345600000000000; Area Measure: 6.1632000000000016

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
E3DB-2412-12-000-DG - Single Panel | PSet_Mass_Property - Mass Measure: 34.5599999999999952; Volume Measure: 0.0345600000000000; Area Measure: 6.1632000000000016
E3DB-2412-12-000-DG - Single Panel | SOLIDWORKS Custom Properties - Description: SINGLE PANEL; PartNo: E3DB-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: HORIZONTAL THRU CUT + RAISED PANEL & GLUED IN POSITION TBC; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
