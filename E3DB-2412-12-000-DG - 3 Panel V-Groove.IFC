Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB-2412-12-000-DG - 3 Panel V-Groove.IFC
Time: 2024-11-05T11:55:09+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 33.2636599199998315; Volume Measure: 0.0332636599199998; Area Measure: 5.9998176121668116

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 33.2636599199998315; Volume Measure: 0.0332636599199998; Area Measure: 5.9998176121668116

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 33.2636599199998315; Volume Measure: 0.0332636599199998; Area Measure: 5.9998176121668116

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
E3DB-2412-12-000-DG - 3 Panel V-Groove | PSet_Mass_Property - Mass Measure: 33.2636599199998315; Volume Measure: 0.0332636599199998; Area Measure: 5.9998176121668116
E3DB-2412-12-000-DG - 3 Panel V-Groove | SOLIDWORKS Custom Properties - Description: 3 PANEL V-GROOVE; PartNo: E3DB-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
