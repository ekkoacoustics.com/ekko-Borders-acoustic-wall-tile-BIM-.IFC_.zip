Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Borders\E3DB-2812-12-000-DG - 3 Panel V-Groove.IFC
Time: 2024-11-05T11:53:22+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 38.8668638399993043; Volume Measure: 0.0388668638399993; Area Measure: 6.9879739158419429

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 38.8668638399993043; Volume Measure: 0.0388668638399993; Area Measure: 6.9879739158419429

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 38.8668638399993043; Volume Measure: 0.0388668638399993; Area Measure: 6.9879739158419429

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
E3DB-2812-12-000-DG - 3 Panel V-Groove | PSet_Mass_Property - Mass Measure: 38.8668638399993043; Volume Measure: 0.0388668638399993; Area Measure: 6.9879739158419429
E3DB-2812-12-000-DG - 3 Panel V-Groove | SOLIDWORKS Custom Properties - Description: 3 PANEL V-GROOVE; PartNo: E3DB-2812-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
